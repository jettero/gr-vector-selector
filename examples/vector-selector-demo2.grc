<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>VectorSelectorDemo2</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>256000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Hz_per_slice</value></param>
<param><key>value</key><value>samp_rate / fft_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>8000</value></param>
<param><key>start</key><value>1000</value></param>
<param><key>stop</key><value>128000</value></param>
<param><key>step</key><value>5000</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui_tab_widget_0</value></param>
<param><key>num_tabs</key><value>3</value></param>
<param><key>label0</key><value>Complex Input</value></param>
<param><key>label1</key><value>FFT Slices</value></param>
<param><key>label2</key><value>Indexes of max() FFT slices</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>input</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>wintype</key><value>firdes.WIN_HAMMING</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0</value></param>
<param><key>freqchangevar</key><value>freq</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_size)</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>vector_selector</key>
<param><key>id</key><value>vector_selector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vec_len</key><value>2</value></param>
<param><key>indices</key><value>0,1</value></param>
<param><key>modality</key><value>grvectorselector.INDEX_MODE</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>vector_selector</key>
<param><key>id</key><value>vector_selector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vec_len</key><value>fft_size</value></param>
<param><key>indices</key><value>0</value></param>
<param><key>modality</key><value>grvectorselector.MINMAX_MODE</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>indexes</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate / fft_size</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>ymax</key><value>fft_size</value></param>
<param><key>update_time</key><value>10</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>fft slices</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate / fft_size</value></param>
<param><key>ymin</key><value>-500</value></param>
<param><key>ymax</key><value>500</value></param>
<param><key>update_time</key><value>10</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_delay</key><value>0.001</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@1</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>vector_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vector_selector_0</source_block_id><sink_block_id>vector_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vector_selector_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vector_selector_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
